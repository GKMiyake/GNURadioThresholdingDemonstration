options:
  parameters:
    generate_options: qt_gui
    id: ThresholdDemonstration
    output_language: python
    title: Threshold Demonstration
  states: {}

blocks:
- name: carrier
  id: variable
  parameters:
    value: rf_samp/16
  states: {}
- name: interpolate
  id: variable
  parameters:
    value: '20'
  states: {}
- name: rf_samp
  id: variable
  parameters:
    value: samp_rate*interpolate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: AM_Modulator_0
  id: AM_Modulator
  parameters:
    af_gain: '0.5'
    carrier: carrier
    interpolate: interpolate
    rf_samp: rf_samp
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '20000'
    audio_stop: '24000'
    chan_rate: samp_rate
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: D:\Documents\Spring 2025\ECSE 351\GNU Radio Project\Fluffing a Duck.mp3
    repeat: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: rf_samp
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [AM_Modulator_0, '0', blocks_float_to_complex_0, '0']
- [AM_Modulator_0, '0', qtgui_time_sink_x_0, '0']
- [analog_am_demod_cf_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', analog_am_demod_cf_0, '0']
- [blocks_wavfile_source_0, '0', AM_Modulator_0, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
