options:
  parameters:
    generate_options: qt_gui
    id: ThresholdDemonstration
    output_language: python
    title: Threshold Demonstration
  states: {}

blocks:
- name: band_pass_tap_0
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: samp_rate/4
    low_cutoff_freq: '-samp_rate/4'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: carrier
  id: variable
  parameters:
    value: rf_samp/4
  states: {}
- name: gain1
  id: variable_qtgui_range
  parameters:
    label: Signal 1
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: gain2
  id: variable_qtgui_range
  parameters:
    label: Signal 2
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: interpolate
  id: variable
  parameters:
    value: '12'
  states: {}
- name: rf_samp
  id: variable
  parameters:
    value: samp_rate*interpolate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: interpolate
    quad_rate: rf_samp
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: rf_samp
    tau: '75e-6'
  states: {}
- name: analog_wfm_tx_0_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: rf_samp
    tau: '75e-6'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain2
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: D:\Documents\Spring 2025\ECSE 351\GNU Radio Project\Fluffing a Duck.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: D:\Documents\Spring 2025\ECSE 351\GNU Radio Project\Monkeys Spinning Monkeys.wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rf_samp
    fc: carrier
    fftsize: '1024'
    name: '"FM Modulated Signal"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Demodulated Signal"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0_0, '0']
- [analog_wfm_rcv_0, '0', qtgui_time_sink_x_0, '0']
- [analog_wfm_tx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_wfm_tx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', analog_wfm_rcv_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_wavfile_source_0, '0', low_pass_filter_0, '0']
- [blocks_wavfile_source_0_0, '0', low_pass_filter_0_0, '0']
- [low_pass_filter_0, '0', analog_wfm_tx_0_0, '0']
- [low_pass_filter_0_0, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
