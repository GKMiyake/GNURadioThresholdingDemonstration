options:
  parameters:
    generate_options: hb
    id: AM_Modulator
    output_language: python
    title: AM Modulator
  states: {}

blocks:
- name: af_gain
  id: parameter
  parameters:
    label: AF Gain
    type: eng_float
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: carrier
    offset: '0'
    phase: '0'
    samp_rate: rf_samp
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: bandwidth
  id: parameter
  parameters:
    label: bandwidth
    value: '3000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: af_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: interpolate
    type: float
  states: {}
- name: carrier
  id: parameter
  parameters:
    label: Carrier Frequency
    type: eng_float
    value: '0'
  states: {}
- name: interpolate
  id: parameter
  parameters:
    label: Interpolation
    type: intx
    value: '1'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: bandwidth
    decim: '1'
    gain: '1'
    samp_rate: rf_samp
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: rf_samp
  id: parameter
  parameters:
    label: RF Sample Rate
    type: eng_float
    value: '0'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', pad_sink_0, '0']
- [blocks_repeat_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [pad_source_0, '0', blocks_repeat_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
