options:
  parameters:
    generate_options: qt_gui
    id: ThresholdDemonstration
    output_language: python
    title: Threshold Demonstration
  states: {}

blocks:
- name: band_pass_tap_0
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: samp_rate/4
    low_cutoff_freq: '-samp_rate/4'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: carrier
  id: variable
  parameters:
    value: rf_samp/4
  states: {}
- name: interpolate
  id: variable
  parameters:
    value: '12'
  states: {}
- name: rf_samp
  id: variable
  parameters:
    value: samp_rate*interpolate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: AM_Modulator_0
  id: AM_Modulator
  parameters:
    af_gain: '1'
    bandwidth: '10200'
    carrier: carrier
    interpolate: interpolate
    rf_samp: rf_samp
  states: {}
- name: AM_Modulator_0_0
  id: AM_Modulator
  parameters:
    af_gain: '1'
    bandwidth: '10200'
    carrier: carrier
    interpolate: interpolate
    rf_samp: rf_samp
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '20000'
    audio_stop: '24000'
    chan_rate: samp_rate
  states: {}
- name: analog_am_demod_cf_0_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '20000'
    audio_stop: '24000'
    chan_rate: samp_rate
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: D:\Documents\Spring 2025\ECSE 351\GNU Radio Project\Fluffing a Duck.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: D:\Documents\Spring 2025\ECSE 351\GNU Radio Project\Monkeys Spinning Monkeys.wav
    repeat: 'True'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: carrier
    decim: interpolate
    samp_rate: rf_samp
    taps: band_pass_tap_0
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: carrier
    decim: interpolate
    samp_rate: rf_samp
    taps: band_pass_tap_0
    type: fcc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: rf_samp
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: rf_samp
    type: float
  states: {}

connections:
- [AM_Modulator_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [AM_Modulator_0, '0', qtgui_freq_sink_x_0, '0']
- [AM_Modulator_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [analog_am_demod_cf_0, '0', blocks_add_xx_0, '0']
- [analog_am_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_am_demod_cf_0_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', audio_sink_0_0, '0']
- [blocks_wavfile_source_0, '0', AM_Modulator_0, '0']
- [blocks_wavfile_source_0_0, '0', AM_Modulator_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_am_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_am_demod_cf_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
